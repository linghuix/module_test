# Keil uVision project modelTest.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rct6
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xE
  c include: ..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\CMSIS\Include;..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Core\Inc;..\Core\0-Conf;..\Core\1-Func;..\Core\2-Task;..\Core\Src;..\Core\Data
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Src
    ../Core/Src/: main.c system_stm32f1xx.c stm32f10x_it.c
  group Startup
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Include/: stm32f1xx.h system_stm32f1xx.h stm32f103xe.h
    ../Startup/: startup_stm32f103xe_keil.s
  group HAL
    ../Core/Src/: stm32f1xx_hal_conf.h
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_wwdg.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c
  group CONF
    ../Core/0-Conf/: BSP.h device_bsp.h bsp_readme.txt BSP.c conf_can.c conf_global.c conf_gpio.c conf_Jlink.c conf_rtc.c conf_spi.c conf_tim.c conf_usart.c conf_adc.c conf_dac.c conf_iic.c
  group FUNC
    ../Core/1-Func/: FUNC.h func_readme.txt func_can.c func_BLE_HC05.c pid.c AO.c PO.c ECON_controller_I.c func_accelerate.c func_beep.c DS18B20.c infrared_HC_SR501.c M8128ForceCollector.c func_dac.c ads1115.c func_adc.c Beijing_driver_control_function.c func_1912.c FSR.c hard_test.c Odrive.c func_rcvCmd.c func_w25qxx.c func_delay.c func_spi.c func_RS485.c DS_300c.c
    ../Core/2-Task/: debug.c systemTimer.c ultrasonic_sensor.c Servos.c prinf_debug_ITM.c led.c
  group TASK
    ../Core/2-Task/: task_readme.txt
  group Data
    ../Core/Data/: win.c
